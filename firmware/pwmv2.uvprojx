# Keil uVision project pwmv2.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F091RCHx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: pwmv2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c demo.c ultrasonic.c config.h delays.h ultrasonic.h demo.h
  group ::CMSIS
    ./: delay.c
software components: CMSIS:CORE 6.1.0, Device:STM32Cube HAL:COMMON 1.11.3, Device:STM32Cube HAL:CORTEX 1.11.3, Device:STM32Cube HAL:FLASH 1.11.3, Device:STM32Cube HAL:GPIO 1.11.3, Device:STM32Cube HAL:RCC 1.11.3, Device:Startup 1.0.0
